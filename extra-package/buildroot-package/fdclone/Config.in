## extra-package/buildroot-package/fdclone/Config.in
```kconfig
config BR2_PACKAGE_FDCLONE
	bool "fdclone"
	help
		A console-based file manager, a clone of FD for DOS.
```
